# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx; MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; SENSOR; RFU
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/B-L475E-IOT01; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lis3mdl; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/lsm6dsl; ../../../../../../Drivers/BSP/Components/vl53l0x; ../../../../../../Middlewares/Third_Party/AWS/include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\Common\AWS\Inc; ..\..\..\WiFi\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\es_wifi
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: B-L475E-IOT01.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration B-L475E-IOT01-FIREWALL (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx; MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; HEAP_DEBUG; FIREWALL_MBEDLIB; SENSOR; RFU
  ILINK.IlinkKeepSymbols: firewall_lib
configuration B-L475E-IOT01-NOSENSOR (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx; MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; RFU
  group Application/Common
    ../../../../../Common/AWS/Src/: aws_iot_test_basic_connectivity.c aws_iot_test_metering.c entropy_hardware_poll.c firewall_wrapper.c heap.c iot_flash_config.c mbedtls_patch.c metering.c network.c network_st_wrapper.c rfu.c sensors_data.c subscribe_publish_sensor_values.c timedate.c timer.c
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: flash_l4.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c vl53l0x_platform.c vl53l0x_proximity.c
  group Application/WIFI
    ../../../WiFi/Src/: es_wifi_io.c wifi.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_tsensor.c
  group Drivers/BSP/Components/ES_WIFI
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/Third_Party/AWS
    ../../../../../../Middlewares/Third_Party/AWS/src/: aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c
  group Middlewares/Third_Party/mbedTLS2.4
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
