# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,SENSOR,RFU
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/vl53l0x;../../../../../../Middlewares/Third_Party/AWS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../Common/AWS/Inc;../../../WiFi/Inc;../../../../../../Drivers/BSP/Components/es_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Application/User
    ../Src/: vl53l0x_platform.c vl53l0x_proximity.c stm32l4xx_hal_msp.c stm32l4xx_it.c flash_l4.c main.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_strings.c vl53l0x_api_core.c vl53l0x_platform_log.c vl53l0x_api_ranging.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_tsensor.c stm32l475e_iot01.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_psensor.c stm32l475e_iot01_magneto.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/AWS
    ../../../../../../Middlewares/Third_Party/AWS/src/: aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_yield.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal.c stm32l4xx_hal_spi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_qspi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rtc.c
  group Application/WIFI
    ../../../WiFi/Src/: wifi.c es_wifi_io.c
  group Drivers/BSP/Components/ES_WIFI
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Application/Common
    ../../../../../Common/AWS/Src/: rfu.c heap.c mbedtls_patch.c entropy_hardware_poll.c firewall_wrapper.c sensors_data.c timedate.c timer.c aws_iot_test_metering.c aws_iot_test_basic_connectivity.c network.c network_st_wrapper.c subscribe_publish_sensor_values.c iot_flash_config.c metering.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Middlewares/Third_Party/mbedTLS2.4
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: asn1parse.c ssl_srv.c camellia.c des.c ssl_ticket.c md.c entropy_poll.c pk_wrap.c x509_create.c sha512.c base64.c pkcs11.c md_wrap.c aes.c xtea.c aesni.c bignum.c pkcs5.c ssl_cookie.c cipher.c ecjpake.c ecp.c cipher_wrap.c md4.c x509_crl.c x509_csr.c ssl_ciphersuites.c version_features.c padlock.c rsa.c cmac.c ssl_cache.c memory_buffer_alloc.c pkparse.c sha256.c timing.c x509_crt.c pkcs12.c ecp_curves.c ssl_tls.c ripemd160.c ctr_drbg.c certs.c gcm.c ssl_cli.c md2.c ccm.c ecdh.c havege.c blowfish.c entropy.c oid.c dhm.c arc4.c x509write_crt.c pem.c platform.c x509write_csr.c pk.c threading.c ecdsa.c sha1.c version.c pkwrite.c x509.c md5.c error.c asn1write.c debug.c hmac_drbg.c
target B-L475E-IOT01-NOSENSOR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: as above
  output: B-L475E-IOT01-NOSENSOR +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,RFU
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
software components: CMSIS:CORE 4.3.0
